# IAR project timer_a_ex2_continousModeOperationWithCCR0Interrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\driverlib\MSP430FR2xx_4xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: timer_a_ex2_continousModeOperationWithCCR0Interrupt.c
  group driverlib/MSP430FR2xx_4xx
    ../../../../driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h ecomp.c ecomp.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h mpy32.c mpy32.h pmm.c pmm.h rtc.c rtc.h sac.c sac.h sfr.c sfr.h sysctl.c sysctl.h tia.c tia.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../../../../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
